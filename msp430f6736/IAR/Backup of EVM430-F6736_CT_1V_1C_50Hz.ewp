# IAR project Backup of EVM430-F6736_CT_1V_1C_50Hz.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xssfn.h
  General.OGChipSelectMenu: MSP430F6736 MSP430F6736
  General.GStackSize2: 256
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: TARGET_IS_MSP430F6xx
  ICC430.newCCIncludePaths: ../; ../driverlib; ../driverlib/MSP430F5xx_6xx; ../emSWLib; ../lib/EM/include; ../lib/mathlib/include; ../EM_Config; ../hal; ../hal/MSP430F5xx_6xx; ../DesignCenter/emDC; ../DesignCenter/comm; ../DesignCenter/guiApp; ../DesignCenter/guiApp/hmiDC
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$/config/lnk430f6736.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: main.c system_pre_init.c
  group DesignCenter/comm
    ../DesignCenter/comm/: comm.c comm.h comm_config.c comm_config.h
  group DesignCenter/comm/drivers
    ../DesignCenter/comm/drivers/: i2cslave.c i2cslave.h i2cslave_defs.h timeout.c timeout.h timeout_defs.h uart.c uart.h uart_defs.h
  group DesignCenter/comm/protocol
    ../DesignCenter/comm/protocol/: checksum.c checksum.h listener.c listener.h packet.c packet.h
  group DesignCenter/comm/utils
    ../DesignCenter/comm/utils/: byte_queue.c byte_queue.h ping_pong_buffer.c ping_pong_buffer.h
  group DesignCenter/emDC
    ../DesignCenter/emDC/: emDCCommandHandlers.c emDCCommandHandlers.h
  group DesignCenter/guiApp
    ../DesignCenter/guiApp/: EMLibGUIApp.c EMLibGUIApp.h
  group DesignCenter/guiApp/hmiDC
    ../DesignCenter/guiApp/hmiDC/: hmi.c hmi.h
  group EM_Config
    ../EM_Config/: emReactivePowerIIRCoeff.h EM_userConfig.c EM_userConfig.h
  group driverlib/MSP430F5xx_6xx
    ../driverlib/MSP430F5xx_6xx/: adc10_a.c adc10_a.h adc12_a.c adc12_a.h aes.c aes.h battbak.c battbak.h comp_b.c comp_b.h crc.c crc.h ctsd16.c ctsd16.h dac12_a.c dac12_a.h dma.c dma.h driverlib.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h flashctl.c flashctl.h gpio.c gpio.h lcd_b.c lcd_b.h ldopwr.c ldopwr.h mpy32.c mpy32.h oa.c oa.h pmap.c pmap.h pmm.c pmm.h ram.c ram.h ref.c ref.h rtc_a.c rtc_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h sd24_b.c sd24_b.h sfr.c sfr.h sysctl.c sysctl.h tec.c tec.h timer_a.c timer_a.h timer_b.c timer_b.h timer_d.c timer_d.h tlv.c tlv.h ucs.c ucs.h usci_a_spi.c usci_a_spi.h usci_a_uart.c usci_a_uart.h usci_b_i2c.c usci_b_i2c.h usci_b_spi.c usci_b_spi.h wdt_a.c wdt_a.h
  group driverlib/MSP430F5xx_6xx/inc
    ../driverlib/MSP430F5xx_6xx/inc/: hw_memmap.h version.h
  group hal/MSP430F5xx_6xx
    ../hal/MSP430F5xx_6xx/: hal.h hal_adc.c hal_adc.h hal_system.c hal_system.h
  group lib/EM/include
    ../lib/EM/include/: emSwLib.h
  group lib/mathlib/include
    ../lib/mathlib/include/: IQmathLib.h QmathLib.h
  group objects
    ../lib/EM/IAR/MSP430F6xx/: EMLib_IAR_MSP430F6xx_large_code_large_data.lib
    ../lib/mathlib/libraries/IAR/: QmathLib_IAR_MPY32_5xx_6xx_CPUX_large_code_large_data.lib IQmathLib_IAR_MPY32_5xx_6xx_CPUX_large_code_large_data.lib
