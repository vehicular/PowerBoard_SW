<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
   <path>$WS_DIR$/EVM430-F6736_CT_1V_1C_50Hz.ewp</path>
  </project>
  <batchBuild/>
</workspace>


